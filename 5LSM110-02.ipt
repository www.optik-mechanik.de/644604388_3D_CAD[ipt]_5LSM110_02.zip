# Autodesk Inventor part: 5LSM110-02
## iProperties
Created: 2007-06
Part Number: 5LSM110-02
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
